# Keil uVision project AW_Project.uvprojx, settings and files
target AW_Pro (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AW_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_ HD,USE_STDPERIPH_DRIVER
  c include: ..\AW_User;..\CORE;..\STM32F10x_FWLib\inc;..\System\delay;..\System\sys;..\System\USARTx;..\PERIP\EXIT;..\PERIP\TIMx;..\PERIP\pwm_TIMx;..\PERIP\Capture_on;..\PERIP\ADC;..\PERIP\DMA\adc_dma;..\PERIP\DMA\usart_dma;..\System\IIC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USWER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dma.c
  group SYSTEM
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/USARTx/: usart.c
    ../System/IIC/: i2c.c
  group PERIP
    ../PERIP/EXIT/: exit.c
    ../PERIP/TIMx/: tim.c
    ../PERIP/pwm_TIMx/: pwm.c
    ../PERIP/Capture_on/: capture.c
    ../PERIP/ADC/: adc.c
    ../PERIP/DMA/usart_dma/: usart_dma.c
    ../PERIP/DMA/adc_dma/: adc_dma.c
